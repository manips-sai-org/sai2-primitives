Commit message: Added Puma example

File: examples/22-puma_singularity/puma.urdf (robot description, URDF)
Before this commit: robot Puma, 7 links, 6 joints
Links:
- link end-effector: geometry 
