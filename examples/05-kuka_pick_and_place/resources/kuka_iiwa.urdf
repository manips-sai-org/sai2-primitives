Commit message: removed gripper

File: examples/05-kuka_pick_and_place/resources/kuka_iiwa.urdf (robot description, URDF)
Before this commit: robot kuka_iiwa, 10 links, 9 joints
Links:
- removed link gripper1
- removed link gripper2
Joints:
- removed joint jgripper1
- removed joint jgripper2
