Commit message: Implemented controller and simulator-visualizer

File: examples/05-kuka_pick_and_place/cube.urdf (robot description, URDF)
Before this commit: robot cube, 2 links, 1 joints
Links:
- link link0: geometry visual mesh filename=./cube.obj scale=1 1 1
